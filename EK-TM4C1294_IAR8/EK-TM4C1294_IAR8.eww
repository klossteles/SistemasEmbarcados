<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TivaWare_C_Series-2.1.4.178\driverlib\driverlib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\fsm_event\fsm_event.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\fsm_matrix\fsm_matrix.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\fsm_state\fsm_state.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\TivaWare_C_Series-2.1.4.178\grlib\grlib.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\Lab2_G09\Lab02_G09.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\Lab3_G09\Lab3_G09.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\CMSIS-5.6.0\CMSIS\RTOS2\RTX\Library\IAR\IDE\RTX_CM.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\simple_display\simple_display.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\simple_io_main_sp\simple_io_main_sp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\simple_io_process_sp\simple_io_process_sp.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Projects\simple_uart\simple_uart.ewp</path>
    </project>
    <batchBuild />
</workspace>
