# IAR project driverlib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C1294NCPDT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: driverlib.srec
  ILINK.IlinkOutputFile: driverlib.out
  group Source
    ./: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c uartstdio.c uartstdio.h udma.c usb.c watchdog.c
